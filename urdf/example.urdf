Commit message: fix joint axis (roll -> pitch)

File: urdf/example.urdf (robot description, URDF)
Before this commit: robot example_3dof_manipulator, 4 links, 3 joints
Joints:
- joint elbow: axis (none) -> 0 -1 0
- joint shoulder: axis (none) -> 0 -1 0
- joint wrist: axis (none) -> 0 -1 0
